## sprdisk/buildroot/package/adb/Config.in
```kconfig
config BR2_PACKAGE_ADB
	bool "adb"
	select BR2_PACKAGE_ZLIB
	select BR2_PACKAGE_OPENSSL
	help
	  Android debug bridge
```
